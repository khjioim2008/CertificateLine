# Keil uVision project InterchangebleCertificateLine-UCOSII-F407V0.2.0.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: InterchangebleCertificateLine-UCOSII-F407V0.2.0
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\SourceFile\Application;..\SourceFile\Auxiliary;..\SourceFile\Auxiliary\DataClass;..\SourceFile\CPU\CORE;..\SourceFile\CPU\STM32F4xx_HAL_Driver\Inc;..\SourceFile\Drive;..\SourceFile\Drive\bsp;..\SourceFile\Drive\External;..\SourceFile\Drive\Internal;..\SourceFile\Resources;..\SourceFile\Drive\Command;..\SourceFile\System;..\SourceFile\UCOSII\uCOSii_Config;..\SourceFile\UCOSII\uCOSii_Port;..\SourceFile\UCOSII\uCOSii_Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../SourceFile/Application/: runCutMachine.c runPagingMachine.c runStampMachine.c
  group Auxilary
    ../SourceFile/Auxiliary/: CRC16.C
    ../SourceFile/Auxiliary/DataClass/: BasicTypes.h dataTypes.h
  group BSP
    ../SourceFile/Drive/bsp/DCMotor/: bsp_BDCMotor.c bsp_BDCMotor.h
    ../SourceFile/Drive/bsp/EncoderTIM/: bsp_EncoderTIM.c bsp_EncoderTIM.h
    ../SourceFile/Drive/bsp/key/: bsp_key.c bsp_key.h
    ../SourceFile/Drive/bsp/Sensor/: bsp_Sensor.c bsp_Sensor.h
    ../SourceFile/Drive/bsp/StepMotor/: bsp_STEPMOTOR.c bsp_STEPMOTOR.h
    ../SourceFile/Drive/bsp/usartx/: bsp_usartx.c bsp_usartx.h
  group Command
    ../SourceFile/Drive/Command/: commandConfig.h commandCore.c commandCore.h commandList.c commandList.h commandUtil.c commandUtil.h
  group CPU
    ../SourceFile/CPU/CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f407xx.s
    ../SourceFile/CPU/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Description
    ../SourceFile/Description/: IO接线.txt 说明.txt
  group Resources
    ../SourceFile/Resources/: Configure.h RAM.c RAM.h Resources.h
  group System
    ../SourceFile/System/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group Drives
    ../SourceFile/Drive/: Drives.h
    ../SourceFile/Drive/External/: motor.c motor.h stepLinkedList.c stepLinkedList.h max6675.c max6675.h pid.c pid.h
    ../SourceFile/Drive/Internal/: usecom.c usecom.h
  group UCOSII_CORE
    ../SourceFile/UCOSII/uCOSii_Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../SourceFile/UCOSII/uCOSii_Port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group UCOSII_CONFIG
    ../SourceFile/UCOSII/uCOSii_Config/: includes.h os_cfg.h
